## boards/training/board.yml
```yaml
board:
  name: training
  full_name: Packt training board
  vendor: nxp
  socs:
  - name: mcxa156
```
